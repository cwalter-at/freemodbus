# Keil uVision project demo.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../modbus/include;./port;../../modbus/rtu;../../modbus/ascii
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Demo
    ./: ADuC702x.s demo.c irq_arm.c
  group modbus
    ../../modbus/: mb.c
    ../../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../modbus/rtu/: mbcrc.c mbrtu.c
    ../../modbus/ascii/: mbascii.c
  group port
    ./port/: port.c portevent.c portserial.c porttimer.c
